Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Sanitary_Toilet-Accessories_Jofel_Stainless-steel-toilet-brush-holder.ifc
Time: 2019-04-30T08:22:17
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement, Stainless steel toilet brush holder
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Stainless steel toilet brush holder; SKU (BO_prodsku): stainless_steel_toilet_brush_holder; ManufacturName (BO_Manufac): Jofel; BrandUrl (BO_brandurl): http://jofel.com; ProductFamily (BO_prodfam): Bath accessories; ProductGroup (BO_prodgroup): Luxury; ManufacturCountry (BO_mancont): Spain; DesignCountry (BO_designcont): Spain; EditionNumber (BO_edinum): 1; Width (BO_width): 89; Height (BO_height): 380; Depth (BO_depth): 89; Weight (BO_weight): 0.78; QR (BO_boqrurl): http://bimobject.com/jofel/product/stainless_steel_toilet_brush_holder; ProductDataUrl (BO_prodaturl): bimobject.com/jofel/product/stainless_steel_toilet_brush_holder; ProductUrl (BO_producturl): http://jofel.com/en/escobillero.html; TechnicalDescription (BO_techcert): http://jofel.com/media/fichas/en/AW61000.pdf; GtinCode (BO_gtin): 8427950325588; MaterialMain (BO_mainmat): Chrome; MaterialSecondary (BO_secmat): Chrome; BimObjectMainCategory (BO_bomaincat): Sanitary; BimObjectMainCategoryCode (BO_bomaincat_code): sanitary; BimObjectCategory (BO_bocat): Toilet Accessories; BimObjectCategoryCode (BO_bocat_code): sanitary-toilet-accessories; IfcClassification (BO_ifcclas): Furnishing Element; UnspcCode (BO_unspc): 30181505; Uniclass14Code (BO_uniclass_1_4_code): L7216; Uniclass14Description (BO_uniclass_1_4_desc): Toilets; Uniclass20Code (BO_uniclass_2_0_code): PR-35-75-86; Uniclass20Description (BO_uniclass_2_0_desc): Toilet Brush Holders; Uniclass2015Code (BO_uniclass2015_code): Pr_40_20_76_86; Uniclass2015Description (BO_uniclass2015_desc): Toilet brush holders; NBSReference (BO_nbs_ref): 35-75-86; NBSReferenceDescription (BO_nbs_desc): Toilet Brush Holders; OmniClassCode (BO_omniclass_code): 23-21 43 15 29; OmniClassDescription (BO_omniclass_name): Toilet Accessories Dispensers; RegionEurope (BO_europe): AL, AT, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FR, GB, GR, HR, HU, IE, IT, LT, LU, LV, MD, ME, MK, NL, NO, PL, PT, RO, RS, RU, SE, SI, SK, UA; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, GF, GY, PE, PY, UY, VE; RegionMiddleEast (BO_middleeast): AE, AF, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BT, CN, GE, ID, IN, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MY, NP, PH, PK, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AU, FJ, NC, NZ, PG, SB, TL, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, DJ, DZ, EH, ER, ET, GA, GH, GN, GQ, GW, KE, LR, LS, LY, MA, MG, ML, MR, MW, MZ, NA, NE, NG, RW, SD, SL, SN, SO, SS, SZ, TD, TG, TN, TZ, UG, ZA, ZM, ZW
